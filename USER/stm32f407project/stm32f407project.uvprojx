# Keil uVision project stm32f407project.uvprojx, settings and files
target stm32f4pro (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\CORE;..\..\FWLIB\inc;.\src;..\..\SYSTEM;..\..\HARDWARE\LED;..\..\MiddleWare\EXTI;..\..\HARDWARE\BEEP;..\..\HARDWARE\KEY;..\..\MiddleWare\UART;..\..\HARDWARE\LCD;..\..\HARDWARE\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group FWLIB
    ../../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../FWLIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group SYSTEM
    ../../SYSTEM/: sub.c sub.h sum.c sum.h delay.c delay.h
  group USER
    ./src/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group HARDWARE
    ../../HARDWARE/LED/: led.c led.h
    ../../HARDWARE/KEY/: key.c key.h
    ../../HARDWARE/BEEP/: beep.c beep.h
    ../../HARDWARE/LCD/: lcd.c lcd.h
    ../../HARDWARE/DHT11/: DHT11.c DHT11.h
  group MiddleWare
    ../../MiddleWare/EXTI/: Exti.c Exti.h
    ../../MiddleWare/UART/: uart.c uart.h
